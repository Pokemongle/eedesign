# Keil uVision project mydemo.uvproj, settings and files
target src (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: mydemo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\demos
  group main
    ./: STARTUP.A51 test1.c STC12C5A.h
