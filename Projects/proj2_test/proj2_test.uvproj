# Keil uVision project proj2_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: proj2_test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Public
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../Public/: STC12C5A.h
