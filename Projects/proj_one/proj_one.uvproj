# Keil uVision project proj_one.uvproj, settings and files
target src (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: proj_one +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Public
  group main
    ./: STARTUP.A51 main.c
  group public
    ../../Public/: STC12C5A.h
  group app
    ../../App/adda/: adda.c adda.h
    ../../App/led/: led.c led.h
