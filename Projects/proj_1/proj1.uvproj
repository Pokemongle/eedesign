# Keil uVision project proj1.uvproj, settings and files
target src (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: proj1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Public;..\..\App
  group main
    ./: STARTUP.A51 main.c
    ../../Public/: STC12C5A.h
  group App
    ../../App/: adda.c adda.h key.c key.h led.c led.h
